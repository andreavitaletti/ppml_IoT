# Keil uVision project Project.uvprojx, settings and files
target L432_NUCLEO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L432_CycloneCrypto +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: STM32L432xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_32,FREERTOS
  c include: .\inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32L4xx_Nucleo_32;..\..\..\myDrivers\errorHandler;..\..\..\myDrivers\printf;..\..\..\Middlewares\Third_Party\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\..\..\Middlewares\Third_Party\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Middlewares\Third_Party\CycloneTCP_SSL_Crypto_Open_1_7_6\cyclone_crypto;..\..\..\Middlewares\Third_Party\CycloneTCP_SSL_Crypto_Open_1_7_6\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Project_files
    ./src/: main.c stm32l4xx_it.c system_stm32l4xx.c
  group BSP
    ../../../Drivers/BSP/STM32L4xx_Nucleo_32/: stm32l4xx_nucleo_32.c
  group HAL
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_dma.c stm32l4xx_hal_qspi.c
  group myDrivers
    ../../../myDrivers/printf/: printf_impl.c
    ../../../myDrivers/errorHandler/: errorHandler.c
  group Startup
    ./: startup_stm32l432xx.s
  group FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c
    ../../../Middlewares/Third_Party/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/Third_Party/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CycloneCrypto
    ../../../Middlewares/Third_Party/CycloneTCP_SSL_Crypto_Open_1_7_6/cyclone_crypto/: aes.c aria.c asn1.c base64.c camellia.c chacha.c chacha20_poly1305.c cipher_mode_cbc.c cipher_mode_ccm.c cipher_mode_cfb.c cipher_mode_ctr.c cipher_mode_ecb.c cipher_mode_gcm.c cipher_mode_ofb.c des.c des3.c dh.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c hmac.c idea.c keccak.c md2.c md4.c md5.c mpi.c oid.c pem.c pkcs5.c poly1305.c rc4.c rc6.c ripemd128.c ripemd160.c rsa.c seed.c sha1.c sha3_224.c sha3_256.c sha3_384.c sha3_512.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c x509.c yarrow.c
  group CycloneCommon
    ../../../Middlewares/Third_Party/CycloneTCP_SSL_Crypto_Open_1_7_6/common/: cpu_endian.c date_time.c debug.c path.c str.c os_port_none.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
